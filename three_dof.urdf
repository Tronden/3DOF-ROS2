Commit message: Update three_dof.urdf

File: three_dof.urdf (robot description, URDF)
Before this commit: robot simple_robot, 6 links, 5 joints
Links:
- removed link column_link
- link base_link: geometry 
Joints:
- removed joint base_to_column
- joint pitch: parent column_link -> base_link
